# Keil uVision project SEEKFREE.uvproj, settings and files
target STC32G12K128 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: SEEKFREE +hex
  link misc: REMOVEUNUSED
  group startup
    ../../Libraries/libraries/: board.c board.h common.c common.h STC32Gxx.h
  group seekfree_libraries
    ../../Libraries/seekfree_peripheral/: headfile.h
    ../../Libraries/seekfree_libraries/: zf_adc.c zf_adc.h zf_delay.c zf_delay.h zf_eeprom.c zf_eeprom.h zf_exti.c zf_exti.h zf_gpio.c zf_gpio.h zf_nvic.c zf_nvic.h zf_pwm.c zf_pwm.h zf_spi.c zf_spi.h zf_tim.c zf_tim.h zf_uart.c zf_uart.h zf_fifo.c zf_fifo.h zf_function.c zf_function.h
  group seekfree_peripheral
    ../../Libraries/seekfree_peripheral/: headfile.h SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_CONFIG.LIB SEEKFREE_CONFIG.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_IMU660RA.c SEEKFREE_IMU660RA.h SEEKFREE_IMU963RA.c SEEKFREE_IMU963RA.h SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h SEEKFREE_TSL1401.c SEEKFREE_TSL1401.h SEEKFREE_VIRSCO.c SEEKFREE_VIRSCO.h SEEKFREE_WIRELESS.c SEEKFREE_WIRELESS.h SEEKFREE_GPS_TAU1201.c SEEKFREE_GPS_TAU1201.h
  group seekfree_components
    ../../Libraries/seekfree_components/: seekfree_assistant.c seekfree_assistant.h seekfree_assistant_inface.c
  group doc
    ../../Libraries/doc/: version.txt
  group user_c
    ../USER/src/: isr.c main.c
  group user_h
    ../USER/inc/: isr.h
  group code
    ../CODE/: readme.txt camera.c camera.h control.c control.h GPS.c GPS.h IMU.c IMU.h menu.c menu.h motor.c motor.h pid.c pid.h show.c show.h VOFA.c VOFA.h
